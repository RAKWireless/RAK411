# Keil uVision project SPI.uvproj, settings and files
target SPI (ARM-ADS)
  device: NANO100LE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1EBFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SPI +hex
  c flags: Optim=1
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Nuvoton\NANO1xx\Include;..\Libraries\NANO1xx_Drivers\Include;..\Libraries\NANO1xx_Libs\spiFlashLib;..\API;..\..\SPI_host_keil;..\API\API_Lib;..\API\API_Lib\include
  memory RVCT4: ROM 0x0 size 0x1ec00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../Libraries/NANO1xx_Drivers/Source/: nano1xx_pdma.c nano1xx_gpio.c nano1xx_sys.c nano1xx_spi.c nano1xx_uart.c
  group Common
    ../Libraries/: nano1xx_retarget.c
    ../Libraries/Device/Nuvoton/NANO1xx/Source/: system_nano1xx.c
  group User
    ../User/: example.c hal_init.c init_wifi_module.c
  group API
    ../API/API_Lib/src/: RAK411_API.c rak_config_init.c rak_spi_apconfig.c rak_spi_auto_connect.c rak_spi_channel.c rak_spi_connect.c rak_spi_disconnect.c rak_spi_easy_config.c rak_spi_get_connect_status.c rak_spi_get_rssi.c rak_spi_get_storeconfig.c rak_spi_get_storeweb.c rak_spi_get_version.c rak_spi_getscan.c rak_spi_interrupt.c rak_spi_interrupt_handler.c rak_spi_ipconfig_dhcp.c rak_spi_ipconfig_query.c rak_spi_open_socket.c rak_spi_ping.c rak_spi_power_mode.c rak_spi_psk.c rak_spi_query_dns.c rak_spi_read_data.c rak_spi_read_packet.c rak_spi_read_status.c rak_spi_reset.c rak_spi_scan.c rak_spi_send_data.c rak_spi_set_ipstatic.c rak_spi_set_listen.c rak_spi_socket_close.c rak_spi_start_web.c rak_spi_store_config.c rak_spi_store_data.c rak_spi_store_web.c rak_spi_sys_init.c rak_spi_wps.c rak_spi_get_tcps.c rak_spi_poll_read_data.c rak_spi_set_funcbitmap.c
